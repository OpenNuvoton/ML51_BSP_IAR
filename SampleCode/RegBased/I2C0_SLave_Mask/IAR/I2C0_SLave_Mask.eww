<?xml version='1.0' encoding='UTF-8'?>
<workspace>
    <project>
        <path>$WS_DIR$\I2C0_SLave_Mask.ewp</path>
    </project>
    <batchBuild />
</workspace>