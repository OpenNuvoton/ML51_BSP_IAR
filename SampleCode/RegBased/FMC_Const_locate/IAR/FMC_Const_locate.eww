<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\FMC_Const_locate.ewp</path>
    </project>
    <batchBuild />
</workspace>
