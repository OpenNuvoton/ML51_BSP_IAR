<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\FMC_ROM_CONST_0x3800.ewp</path>
    </project>
    <batchBuild />
</workspace>
