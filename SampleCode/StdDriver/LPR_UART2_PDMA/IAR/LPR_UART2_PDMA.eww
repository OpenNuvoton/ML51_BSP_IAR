<?xml version='1.0' encoding='UTF-8'?>
<workspace>
    <project>
        <path>$WS_DIR$\LPR_UART2_PDMA.ewp</path>
    </project>
    <batchBuild />
</workspace>