<?xml version='1.0' encoding='UTF-8'?>
<workspace>
    <project>
        <path>$WS_DIR$\ACMP_Wakeup_ML51_64KB_32KB_ML54_ML56.ewp</path>
    </project>
    <batchBuild />
</workspace>