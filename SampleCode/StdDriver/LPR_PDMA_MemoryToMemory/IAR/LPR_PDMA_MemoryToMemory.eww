<?xml version='1.0' encoding='UTF-8'?>
<workspace>
    <project>
        <path>$WS_DIR$\LPR_PDMA_MemoryToMemory.ewp</path>
    </project>
    <batchBuild />
</workspace>