<?xml version='1.0' encoding='UTF-8'?>
<workspace>
    <project>
        <path>$WS_DIR$\IAP_APROM_CRC_ML51_64KB_ML54_ML56.ewp</path>
    </project>
    <batchBuild />
</workspace>