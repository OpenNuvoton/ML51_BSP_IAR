# IAR project LCD_NK_LCDView_ML54_ML56.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: ML51 ML51
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\..\..\Library\Device\Include; ..\..\..\..\Library\StdDriver\inc
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  postbuild: cmd /C ""$TOOLKIT_DIR$\..\..\..\Nuvoton Tools\Nu-Link_IAR\Hex2Bin.exe" "Debug\Exe\$TARGET_BNAME$.a51""
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\NuvoTon\lnk51ew_ML51.xcl
configuration Release (8051)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: N76E003 N76E003
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../: main.c
  group LCD
    ../: lcd_nk.c lcd_view.c
  group Library
    ../../../../Library/StdDriver/src/: common.c delay.c lcd.c
  group Startup
    ../../../../Library/Startup/IAR/: cstartup.s51
