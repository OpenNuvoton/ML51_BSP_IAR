# IAR project Project_temp.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: Unable to find default state
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\..\..\Library\Device\Include; ..\..\..\..\Library\StdDriver\inc
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\NuvoTon\lnk51ew_ML51.xcl
configuration Release (8051)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: N76E003 N76E003
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../../../../Library/StdDriver/src/: acmp.c adc.c bod.c capture.c common.c delay.c eeprom.c eeprom_sprom.c exint.c gpio.c i2c.c IAP.c lcd.c lowpwer.c pdma.c pinint.c power.c pwm0.c pwm123.c rtc.c spi.c sys.c TrimLIRC.c uart.c uart2.c uart3.c vref.c wdt.c wkt.c
    ../: HelloWorld.c
